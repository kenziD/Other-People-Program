# Keil uVision project ANO_FLY.uvprojx, settings and files
target ANO_FLY (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ANO_FLY +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --c99
  c include: .\LIB;..\ANO_FLY
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group LIB
    ./LIB/: stm32f10x_conf.h startup_stm32f10x_md.s system_stm32f10x.c core_cm3.c misc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_dma.c
  group BSP
    ./BSP/: BSP.c BSP.h Tim.c Tim.h Usart.c Usart.h Nrf24l01.h Spi.c Spi.h Led.c Led.h Moto.c moto.h Nrf24l01.C eeprom.c eeprom.h ADC.c ADC.h
  group APP_SYS
    ./APP/SYS/: main.c stm32f10x_it.c
  group I2C_6050
    ./APP/I2C_6050/: I2C_MPU6050.c
  group APP_UART
    ./APP/UART/: Uart1.c Uart1.h
  group APP_RC
    ./APP/RC/: Rc.c Rc.h
  group APP_IMU
    ./APP/IMU/: IMU.c IMU.h
  group APP_CONTROL
    ./APP/CONTROL/: Control.c Control.h
