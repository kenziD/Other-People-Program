# Keil uVision project ANO_USB.uvproj, settings and files
target ANO_USB (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ANO_USB +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --c99
  c include: ..\ANO_USB;.\LIB;.\BSP;.\APP\5110
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group LIB
    ./LIB/: stm32f10x_conf.h startup_stm32f10x_md.s system_stm32f10x.c core_cm3.c misc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_dma.c
  group BSP
    ./BSP/: BSP.c BSP.h Tim.c Tim.h Usart.c Usart.h Nrf24l01.h Spi.c Spi.h Nrf24l01.C Led.c
  group APP_SYS
    ./APP/SYS/: main.c stm32f10x_it.c
  group APP_UART
    ./APP/UART/: Uart1.c Uart1.h
  group APP_RC
    ./APP/RC/: Rc.c Rc.h
  group DMA_ADC
    ./BSP/: DMA_ADC.c
  group 5110
    ./APP/5110/: Delay_5110.c LCD5110.c
